# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3
  c define: USE_HAL_DRIVER,STM32L475xx
  c misc: --diag_suppress=188 --diag_suppress=111 --diag_suppress=550
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Core/Delay;../Core/LCD;../Core/LED;../Core/User;..\Core\lvgl;..\Core\lvgl\src;..\Core\lvgl\src\core;..\Core\lvgl\src\draw;..\Core\lvgl\src\extra;..\Core\lvgl\src\font;..\Core\lvgl\src\hal;..\Core\lvgl\src\misc;..\Core\lvgl\src\widgets;..\Core\lvgl\porting;..\Core\lvgl\UserCode;..\Core\lvgl\examples\get_started;..\Core\lvgl\examples\anim
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
    ../Core/Inc/: main.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group LCD
    ../Core/LCD/: LCD.c LCD.h
  group LED
    ../Core/LED/: LED.c LED.h
  group delay
    ../Core/Delay/: Delay.c Delay.h
  group LVGL_Core
    ../Core/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_theme.c lv_refr.c
  group LVGL_Draw
    ../Core/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Core/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Core/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Core/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Core/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Core/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Core/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Core/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Core/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL_Extra
    ../Core/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Core/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Core/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Core/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Core/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Core/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Core/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Core/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Core/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Core/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Core/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Core/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Core/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Core/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Core/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Core/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Core/lvgl/src/extra/others/msg/: lv_msg.c
    ../Core/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Core/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Core/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Core/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Core/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Core/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Core/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Core/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Core/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Core/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Core/lvgl/src/extra/widgets/led/: lv_led.c
    ../Core/lvgl/src/extra/widgets/list/: lv_list.c
    ../Core/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Core/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Core/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Core/lvgl/src/extra/widgets/span/: lv_span.c
    ../Core/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Core/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Core/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Core/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Core/lvgl/src/extra/widgets/win/: lv_win.c
    ../Core/lvgl/src/extra/: lv_extra.c
  group LVGL_Font
    ../Core/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL_HaL
    ../Core/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_Misc
    ../Core/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL_Widget
    ../Core/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Porting
    ../Core/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL_Demo
    ../Core/lvgl/examples/get_started/: lv_example_get_started_1.c
    ../Core/lvgl/examples/anim/: lv_example_anim_1.c
  group LVGL_Header
    ../Core/lvgl/: lvgl.h lv_conf.h
  group User_LVGL
    ../Core/lvgl/UserCode/: user_lvgl.c user_lvgl.h
software components: CMSIS:CORE 4.3.0
